Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_3/temp/tmp_4432_336_hW7Sn/format_0/911506003001(architecture=300).ifc
Time: 2024-01-17T09:39:35
Made in: PARTsolutions

# IfcProject, 911506003001(architecture=300)
Description: NUEVA wash bowl 3194

# IfcDiscreteAccessory, 911506003001(architecture=300)
In: BUILDING
Description: 911506003001(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 911506003001
ePset_PARTsolutions - NB: 911506003001(architecture=300); NN: 911506003001; NT: NUEVA wash bowl 3194; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 911506003001(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 911506003001; B: 3194.png; C: NUEVA wash bowl 3194; D: 4.3; E: KALDEWEI; F: 4055761329538; M: Furnishing Element; N: IfcSanitaryTerminalType; O: SS-35-65-70-94; P: Wash Basin Systems; Q: 23-31-13-11; R: RVT_METRICPLUMBINGFIXTURE; S: EC011550; EF002169: enamelled steel (EV000166); EF000139: Enamelled (EV002029); EF000051: round Bowl (EV000167); EF000007: alpine white (EV000202); EF000003: post top (EV003651); EF000049: 320; EF004567: 320; EF000040: 127
